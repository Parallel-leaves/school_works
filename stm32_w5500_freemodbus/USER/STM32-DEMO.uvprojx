# Keil uVision project STM32-DEMO.uvprojx, settings and files
target STM32_Modbus_TCP V1.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Modbus_TCP_V1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\inc;..\modbus\ascii;..\modbus\functions;..\modbus\include;..\modbus\port;..\modbus\tcp;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./src/: led.c main.c stm32f10x_it.c System_Init.c SysTick.c usart1.c W5500.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Modbus
    ../modbus/ascii/: mbascii.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/rtu/: mbcrc.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/: mb.c
  group Port
    ../modbus/port/: portevent.c porttcp.c
software components: CMSIS:CORE 5.4.0
